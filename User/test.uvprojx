# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=1
  c include: ..\Lib\driverlib\MSP432P4xx;..\Lib\driverlib\MSP432P4xx\keil;..\rt-thread\bsp;..\rt-thread\include;..\rt-thread\include\libc;..\rt-thread\components\finsh
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group User
    ./: main.c
  group Lib
    ../Lib/driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
  group Bsp
    ../rt-thread/bsp/: board.c rtconfig.h
    ../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group RT_Thread
    ../rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group Finsh
    ../rt-thread/components/finsh/: cmd.c finsh_port.c msh.c shell.c
software components: CMSIS:CORE 5.5.0, Device:Startup 3.2.2
